IMAGE_FEATURES:remove:armefi64 = "splash"
